Commit message: added isSufficient to validity checker

File: data/Lshape/Xshape_sphere_outer.urdf (robot description, URDF)
Before this commit: robot Xshape_sphere_outer, 1 links, 0 joints
Links:
- link body: geometry collision sphere radius=1.56524758425; visual sphere radius=1.56524758425
