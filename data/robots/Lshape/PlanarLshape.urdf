Commit message: Imported files from OMPL repo

File: data/robots/Lshape/PlanarLshape.urdf (robot description, URDF)
Before this commit: robot Lshape/PlanarLshape, 3 links, 2 joints
Links:
- link link2: geometry collision box size=0.7 1.19999 0.1; visual box size=0.7 1.19999 0.1
