Commit message: refactored openset and cover module

File: data/robots/Xshape_sphere_inner.urdf (robot description, URDF)
Before this commit: robot Xshape_sphere_inner, 1 links, 0 joints
Links:
- link body: geometry collision sphere radius=0.05; visual sphere radius=0.05
