Commit message: Minor changes to experiments

File: data/robots/drone/dddk.urdf (robot description, URDF)
Before this commit: robot dragon_ddk, 4 links, 3 joints
Links:
- link base_link: geometry collision mesh filename=meshes/dddk.stl; visual mesh filename=meshes/dddk.stl
