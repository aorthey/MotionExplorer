Commit message: Fix outer sphere Xshape

File: data/robots/Xshape_sphere_outer.urdf (robot description, URDF)
Before this commit: robot Xshape_sphere_outer, 1 links, 0 joints
Links:
- link body: geometry collision sphere radius=1.70073513517; visual sphere radius=1.70073513517
