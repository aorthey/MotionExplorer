Commit message: update on experiments

File: data/robots/snake_sphere_inner.urdf (robot description, URDF)
Before this commit: robot robots/snake_sphere_inner, 1 links, 0 joints
Links:
- link body: geometry collision sphere radius=0.2; visual sphere radius=0.2
