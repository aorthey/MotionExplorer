Commit message: Extension of Validity Checker

File: data/objects/cylinder_variable.urdf (robot description, URDF)
Before this commit: robot cylinder, 1 links, 0 joints
Links:
- link body: geometry collision cylinder length=0.1 radius=0.1; visual cylinder length=0.1 radius=0.1
