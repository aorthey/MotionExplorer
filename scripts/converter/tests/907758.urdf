Commit message: Add additional experiments.

File: scripts/converter/tests/907758.urdf (robot description, URDF)
Before this commit: robot 907758, 1 links, 0 joints
Links:
- link body: geometry collision mesh filename=907758.stl; visual mesh filename=907758.stl
